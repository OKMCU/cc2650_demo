# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.IExtraOptions: -f; configPkg/compiler.opt.defs; --diag_suppress=Pa050; -I$CC26XXWARE$; -Dewarm; --debug; --silent
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: pwmled.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: $PROJ_FNAME$_CC2650_LAUNCHXL.icf
  ILINK.IlinkExtraOptions: -f; configPkg/linker.cmd; $CC26XXWARE$/driverlib/bin/iar/driverlib.lib; --silent; --cpu=Cortex-M3; --entry=__iar_program_start; --redirect; _Printf=_PrintfSmall; --redirect; _Scanf=_ScanfSmall
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group PWM LED/Configuration files
    ./: project.cfg
  group PWM LED/Documentation
    ./: README.html
  group PWM LED/Header files
    ./: Board.h CC2650_LAUNCHXL.h
  group PWM LED/Source files
    ./: CC2650_LAUNCHXL.c ccfg.c project_CC2650_LAUNCHXL.icf pwmled.c
